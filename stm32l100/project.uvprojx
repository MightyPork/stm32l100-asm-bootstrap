# Keil uVision project project.uvprojx, settings and files
target MAIN (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L100RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group main
    ./: startup_stm32l100xc.s MAIN.asm
software components: CMSIS:CORE 4.2.0
